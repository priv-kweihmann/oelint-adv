LICENSE = "CLOSED"

inherit core-image
inherit testimage
