LICENSE = "CLOSED"

inherit image-live
inherit grub-efi-cfg
inherit syslinux
