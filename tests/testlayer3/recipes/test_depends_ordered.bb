DEPENDS = "b"

require test_depends_ordered.inc
