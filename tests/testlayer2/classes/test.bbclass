require conf/machine/include/test.inc
