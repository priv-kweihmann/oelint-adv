FOO_BAR:intel-core2-32 = "1"
