FOO_BAR:testdistro = "1"
