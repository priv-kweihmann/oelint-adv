FOO_BAR:testmachine = "1"
