require conf/machine/include/test.inc

MY_VARIABLE:class-native = "1"
